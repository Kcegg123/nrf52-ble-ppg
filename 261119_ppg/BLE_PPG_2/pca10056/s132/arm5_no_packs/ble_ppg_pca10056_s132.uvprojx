# Keil uVision project ble_ppg_pca10056_s132.uvprojx, settings and files
target nrf52840_xxaa (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD NRF_SD_BLE_API_VERSION=3 S132 CONFIG_GPIO_AS_PINRESET BOARD_PCA10056 SOFTDEVICE_PRESENT NRF52840_XXAA SWI_DISABLE0
  c include: ..\..\..\config\ble_ppg_pca10056_s132;..\..\..\config;..\..\..\..\..\SDK12\components;..\..\..\..\..\SDK12\components\device;..\..\..\..\..\SDK12\components\toolchain;..\..\..\..\..\SDK12\components\toolchain\cmsis\include;..\..\..\..\..\SDK12\components\ble\ble_advertising;..\..\..\..\..\SDK12\components\ble\ble_dtm;..\..\..\..\..\SDK12\components\ble\ble_racp;..\..\..\..\..\SDK12\components\ble\ble_services\ble_ancs_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_ans_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_bas;..\..\..\..\..\SDK12\components\ble\ble_services\ble_bas_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_cscs;..\..\..\..\..\SDK12\components\ble\ble_services\ble_cts_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_dfu;..\..\..\..\..\SDK12\components\ble\ble_services\ble_dis;..\..\..\..\..\SDK12\components\ble\ble_services\ble_gls;..\..\..\..\..\SDK12\components\ble\ble_services\ble_hids;..\..\..\..\..\SDK12\components\ble\ble_services\ble_hrs;..\..\..\..\..\SDK12\components\ble\ble_services\ble_hrs_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_hts;..\..\..\..\..\SDK12\components\ble\ble_services\ble_ias;..\..\..\..\..\SDK12\components\ble\ble_services\ble_ias_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_lbs;..\..\..\..\..\SDK12\components\ble\ble_services\ble_lbs_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_lls;..\..\..\..\..\SDK12\components\ble\ble_services\ble_nus;..\..\..\..\..\SDK12\components\ble\ble_services\ble_nus_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_rscs;..\..\..\..\..\SDK12\components\ble\ble_services\ble_rscs_c;..\..\..\..\..\SDK12\components\ble\ble_services\ble_tps;..\..\..\..\..\SDK12\components\ble\common;..\..\..\..\..\SDK12\components\ble\nrf_ble_qwr;..\..\..\..\..\SDK12\components\ble\peer_manager;..\..\..\..\..\SDK12\components\boards;..\..\..\..\..\SDK12\components\drivers_nrf\adc;..\..\..\..\..\SDK12\components\drivers_nrf\clock;..\..\..\..\..\SDK12\components\drivers_nrf\common;..\..\..\..\..\SDK12\components\drivers_nrf\comp;..\..\..\..\..\SDK12\components\drivers_nrf\delay;..\..\..\..\..\SDK12\components\drivers_nrf\gpiote;..\..\..\..\..\SDK12\components\drivers_nrf\hal;..\..\..\..\..\SDK12\components\drivers_nrf\i2s;..\..\..\..\..\SDK12\components\drivers_nrf\lpcomp;..\..\..\..\..\SDK12\components\drivers_nrf\pdm;..\..\..\..\..\SDK12\components\drivers_nrf\power;..\..\..\..\..\SDK12\components\drivers_nrf\ppi;..\..\..\..\..\SDK12\components\drivers_nrf\pwm;..\..\..\..\..\SDK12\components\drivers_nrf\qdec;..\..\..\..\..\SDK12\components\drivers_nrf\rng;..\..\..\..\..\SDK12\components\drivers_nrf\rtc;..\..\..\..\..\SDK12\components\drivers_nrf\saadc;..\..\..\..\..\SDK12\components\drivers_nrf\spi_master;..\..\..\..\..\SDK12\components\drivers_nrf\spi_slave;..\..\..\..\..\SDK12\components\drivers_nrf\swi;..\..\..\..\..\SDK12\components\drivers_nrf\timer;..\..\..\..\..\SDK12\components\drivers_nrf\twi_master;..\..\..\..\..\SDK12\components\drivers_nrf\twis_slave;..\..\..\..\..\SDK12\components\drivers_nrf\uart;..\..\..\..\..\SDK12\components\drivers_nrf\usbd;..\..\..\..\..\SDK12\components\drivers_nrf\wdt;..\..\..\..\..\SDK12\components\libraries\bsp;..\..\..\..\..\SDK12\components\libraries\button;..\..\..\..\..\SDK12\components\libraries\crc16;..\..\..\..\..\SDK12\components\libraries\crc32;..\..\..\..\..\SDK12\components\libraries\csense;..\..\..\..\..\SDK12\components\libraries\csense_drv;..\..\..\..\..\SDK12\components\libraries\experimental_section_vars;..\..\..\..\..\SDK12\components\libraries\fds;..\..\..\..\..\SDK12\components\libraries\fstorage;..\..\..\..\..\SDK12\components\libraries\gpiote;..\..\..\..\..\SDK12\components\libraries\hardfault;..\..\..\..\..\SDK12\components\libraries\hci;..\..\..\..\..\SDK12\components\libraries\led_softblink;..\..\..\..\..\SDK12\components\libraries\log;..\..\..\..\..\SDK12\components\libraries\log\src;..\..\..\..\..\SDK12\components\libraries\low_power_pwm;..\..\..\..\..\SDK12\components\libraries\mem_manager;..\..\..\..\..\SDK12\components\libraries\pwm;..\..\..\..\..\SDK12\components\libraries\queue;..\..\..\..\..\SDK12\components\libraries\scheduler;..\..\..\..\..\SDK12\components\libraries\sensorsim;..\..\..\..\..\SDK12\components\libraries\slip;..\..\..\..\..\SDK12\components\libraries\timer;..\..\..\..\..\SDK12\components\libraries\twi;..\..\..\..\..\SDK12\components\libraries\uart;..\..\..\..\..\SDK12\components\libraries\usbd;..\..\..\..\..\SDK12\components\libraries\usbd\class\audio;..\..\..\..\..\SDK12\components\libraries\usbd\class\cdc;..\..\..\..\..\SDK12\components\libraries\usbd\class\cdc\acm;..\..\..\..\..\SDK12\components\libraries\usbd\class\hid;..\..\..\..\..\SDK12\components\libraries\usbd\class\hid\generic;..\..\..\..\..\SDK12\components\libraries\usbd\class\hid\kbd;..\..\..\..\..\SDK12\components\libraries\usbd\class\hid\mouse;..\..\..\..\..\SDK12\components\libraries\usbd\class\msc;..\..\..\..\..\SDK12\components\libraries\usbd\config;..\..\..\..\..\SDK12\components\libraries\util;..\..\..\..\..\SDK12\components\softdevice\common\softdevice_handler;..\..\..\..\..\SDK12\components\softdevice\s132\headers;..\..\..\..\..\SDK12\components\softdevice\s132\headers\nrf52;..\..\..\..\..\SDK12\components\toolchain;..\..\..\..\..\SDK12\external\segger_rtt;..\config
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-DNRF_SD_BLE_API_VERSION=3,-DS132,-DCONFIG_GPIO_AS_PINRESET,-DBOARD_PCA10056,-DSOFTDEVICE_PRESENT,-DNRF52840_XXAA,-DSWI_DISABLE0
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0xe1000
  memory RVCT9: RAM 0x20002800 size 0x3d800
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../../../../SDK12/components/boards/: boards.c
  group Board Support
    ../../../../../SDK12/components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group nRF_BLE
    ../../../../../SDK12/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../../SDK12/components/ble/ble_advertising/: ble_advertising.c
    ../../../../../SDK12/components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
  group nRF_Drivers
    ../../../../../SDK12/components/drivers_nrf/clock/: nrf_drv_clock.c
    ../../../../../SDK12/components/drivers_nrf/common/: nrf_drv_common.c
    ../../../../../SDK12/components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ../../../../../SDK12/components/drivers_nrf/uart/: nrf_drv_uart.c
  group nRF_Libraries
    ../../../../../SDK12/components/libraries/button/: app_button.c
    ../../../../../SDK12/components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ../../../../../SDK12/components/libraries/timer/: app_timer.c
    ../../../../../SDK12/components/libraries/crc16/: crc16.c
    ../../../../../SDK12/components/libraries/fds/: fds.c
    ../../../../../SDK12/components/libraries/fstorage/: fstorage.c
    ../../../../../SDK12/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../../SDK12/components/libraries/sensorsim/: sensorsim.c
  group nRF_Log
    ../../../../../SDK12/components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group nRF_Segger_RTT
    ../../../../../SDK12/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_SoftDevice
    ../../../../../SDK12/components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group Startup
    ../../../../../SDK12/components/toolchain/arm/: arm_startup_nrf52840.s
    ../../../../../SDK12/components/toolchain/: system_nrf52840.c
target flash_s132_nrf52_3.0.0_softdevice (ARM-ADS)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: ..
  cpu: as above
  output: s132_nrf52_3.0.0_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c include: ..\..\..\config\ble_ppg_pca10056_s132;..\..\..\config;..\config
  asm misc: --cpreproc_opts=
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0xe1000
  memory RVCT9: RAM 0x20002800 size 0x3d800
  group left out of the first target's files
    ../../../../../SDK12/components/toolchain/arm/: arm_startup_nrf52840.s
    ../../../../../SDK12/components/toolchain/: system_nrf52840.c
